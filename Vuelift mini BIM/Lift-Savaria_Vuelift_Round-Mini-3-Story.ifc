Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
Time: 2023-01-26T16:11:23
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.5.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 ft
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1582
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Lift-Savaria_Vuelift_Round-Mini-3-Story:Round Mini - White Sandtex, Lift-Savaria_Vuelift_Round-Mini-3-Story:Round Mini - White Sandtex:183964
In: Level 1
Type - Material: <Unnamed>, Powder Coat - Savaria - White Sandtex, Glass
Type - Constraints - Default Elevation: 0 ft
Type - Dimensions - 78" H Cab: 6.5 ft; Hoistway Door: 6.5 ft
Type - Identity Data - Applied Code: ASME 17.1-2013 SEC. 5.3; Cabinet Floor Area: 39", 8.25 ft2, 1m, 0.75 m2; Cabinet Interior Height: 78'' [1.98 m]; Cabinet Weight: 550 lb 250 kg; Capacity: 500lbs [227 kg]; Classification: Residential Building; Copyright: © Copyright 2020 Savaria.; Manufacturer: Savaria; Model: Round Mini Acrylic; Number of Floors: 3 Max.; OmniClass Number: 23.50.05.14; OmniClass Title: Lifts; Power Supply: 60 Hz Single Phase 240 volt (60Hz); Specification: https://276ajivls9v24coqa255x2fb-wpengine.netdna-ssl.com/wp-content/uploads/2020/08/Mini-Vuelift-brochure-WEB-2020_08.pdf; Type Name: Round Mini - White Sandtex; URL: https://www.savaria.com/; Walls: Clear Acrylic - ANSI Z97.1
Type - Materials and Finishes - Frame: Powder Coat - Savaria - White Sandtex; Glass: Glass
Type - Other - Category: Generic Models; Family Name: Lift-Savaria_Vuelift_Round-Mini-3-Story
Type - Pset_ManufacturerTypeInformation - Manufacturer: Savaria
Type - Pset_ProductRequirements - Category: Generic Models
Material: Powder Coat - Savaria - White Sandtex, BLACK, Glass, Powder Coat - Savaria - Black Sandtex, Yallow, Red Button, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Round Mini - White Sandtex; sets with these values: 2
Constraints - Elevation from Level: 0 ft; Host: Basic Wall : Wall 1; Offset from Host: 0 ft
Dimensions - Angle: 0 deg; Angle XX (default): 0 deg; Area: 765.988 ft2; Cabin Offset From L1: 0 ft; Height from Top Floor to Elevator Top: 8 ft; L1_Ceiling_Height: 11.6667 ft; L2_ Finish Floor: 12.5 ft; L3_ Finish Floor: 23.3333 ft; Volume: 20.1458 ft3
Other - Family: Lift-Savaria_Vuelift_Round-Mini-3-Story; Family and Type: Lift-Savaria_Vuelift_Round-Mini-3-Story: Round Mini - White Sandtex; Type: Round Mini - White Sandtex; Type Id: 183939
Phasing - Phase Created: New Construction
Visibility - Cabin Door Closed: yes; Cabin Door Open: no; Cabin Visibility: yes; Clearance: yes; L1_Door Postion Left Side: no; L1_Door Postion Right Side: yes; L1 Top Frame Visibility: yes; L2_Door Postion Left Side: no; L2_Door Postion Right Side: yes; L2 Balcony Plate: yes; L2 Top Frame Visibility: yes; L3_Door Postion Left Side: no; L3_Door Postion Right Side: yes; L3 Balcony Plate: yes; L3 Top Frame Visibility: yes

# IfcDistributionPort, Port_183964
Description: Flow; FlowDirection: SOURCEANDSINK
